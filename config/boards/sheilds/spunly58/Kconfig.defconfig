## config/boards/shields/spunly58/Kconfig.defconfig
```kconfig
if SHIELD_SPUNLY58

config ZMK_KEYBOARD_NAME
    default "Ergo63keyboard"

endif
```
